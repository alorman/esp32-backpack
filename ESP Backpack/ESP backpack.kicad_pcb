# Repository alorman/esp32-backpack

File README.md:

# esp32-backpack
This board is designed to couple to the back of the the [DC Metro Map](https://github.com/alorman/dc-map-500x500) and drive the LEDs.  
This daughterboard-style design is to allow for rapid iteration and testing on the driving board, while keeping the large and expensive map PCB separate.

## Images

## Schematic
[Schematic](exports/esp32-backpack-schematic.pdf)

## BOM
[Interactive BOM](exports/ibom.html)

## ESP Chipsets
ESP32 Chipsets come in about a zillion different configurations. To support the [code](https://github.com/alorman/dc_metro_map) you need a dual-core version. 

This board supports:
| Dev Kit Name         | Module           | Chipset       | Cores | Flash | SPRAM | Notes                 |
|----------------------|------------------|---------------|-------|-------|-------|-----------------------|
| ESP32-DevKitCVE      | ESP32-WROVER-E   | ESP32-D0WD-V3 | 2     | 4 MB  | 8 MB  | Full Size PCB Antenna |
| ESP32-DevKitC-32E    | ESP32-WROOM-32E  | ESP32-D0WD-V3 | 2     | 4 MB  | 4 MB  | Full Size PCB Antenna |
| ESP32-WROOM-32UE     | ESP32­WROOM­32UE | ESP32-D0WD-V3 | 2     | 4 MB  | 4 MB  | u.FL Connector        |
| HiLetgo ESP-WROOM-32 | ESP32-WROOM-32D  | ESP32-D0WD    | 2     | 4 MB  | 4 MB  | NRND, Amazon          |

Note: the HiLetGo (and likely other Amazonian boards) require a slight bending of the pins to fit.

## Fab Instructions
| | |
|-------------------|---------------:|
| Height (mm)       | 100            |
| Width (mm)        | 100            |
| Layers            | 2              |
| Thickness (mm)    | 1.6            |
| Solder Mask       | Black          |
| Silkscreen        | White          |
| Copper Thickness  | 1 oz           |
| Min Spacing       | 8/8mil         |
| Min Hole Size     | 8mil           |
| Via Process       | Tented         |
| Surface Treatment | HASL-Lead Free |
| Special Notes     | None           |

## KiCad design ESP Backpack/ESP backpack.kicad_pcb

Parts:
5VDC_IN1: 282837-2; TE_282837-2
BT1: Battery_Cell; Keystone_2894
C1, C11, C12: 10uF; C_0603_1608Metric
C2: 0.1uF; C_0805_2012Metric
C3, C4, C5, C6, C7, C8, C9, C10: A765MU158M1ALAE014; CAP_EEE0JA102P
C13: 0.1uF; C_0603_1608Metric
D1: SK6812; LED_SK6812; PARTREV 03
ExtPower1: 0ohm; R_0603_1608Metric
F1: Fuse; Keystone-3658
J1, J2: HLE-120-02-F-DV-BE-K; SAMTEC_HLE-120-02-F-DV-BE-K
J3: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
JReset1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R8, R9: 10k; R_0603_1608Metric
R3, R4, R5, R6, R7, R10: 470; R_0603_1608Metric
S1, S2: 452403012014
SCL1, SCL2: 0ohm; R_0603_1608Metric
SCL_EXT1: 0ohm; R_0603_1608Metric
SDA1, SDA2: 0ohm; R_0603_1608Metric
SDA_EXT1: 0ohm; R_0603_1608Metric
U1: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D; PARTREV 4
U2: VCNL4010-GS08; XDCR_VCNL4010-GS08; PARTREV 1.6
U3: DS3231SN#; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+3V3: C1.1, C2.1, C12.2, C13.2, J1.35, R1.2, R2.2, S1.2, S2.2, U1.1 (3V3), U2.1, U2.7, U3.2 (Vcc)
+5V: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, D1.1 (VDD), ExtPower1.1, F1.2, J1.01, J1.03, J1.05, J1.07, J1.09, J1.11, J1.13, J1.15, J1.17, J1.19, J1.21, J1.23, J1.25, J1.27, J1.29, J1.31, J1.33, J2.01, J2.03, J2.05, J2.07, J2.09, J2.11, J2.13, J2.15, J2.17, J2.19, J2.21, J2.23, J2.25, J2.27, J2.29, J2.31, J2.33, J2.35, J2.37, J2.39
/BlueLine: J2.16, R6.2
/DiagLED: D1.4 (DIN), R10.2
/GreenLine: J2.12, R5.2
/OrangeLine: J2.04, R3.2
/RedLine: J2.20, R7.2
/SCL: R2.1, SCL1.1, SCL2.2, SCL_EXT1.2, U1.22 (IO22)
/SDA: R1.1, SDA1.1, SDA2.2, SDA_EXT1.2, U1.25 (IO21)
/YellowLine: J2.08, R4.2
GND: 5VDC_IN1.1, BT1.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.1, C13.1, D1.3 (VSS), J1.02, J1.04, J1.06, J1.08, J1.10, J1.12, J1.14, J1.16, J1.18, J1.20, J1.22, J1.24, J1.26, J1.28, J1.32, J1.36, J1.40, J2.02, J2.06, J2.10, J2.14, J2.18, J2.22, J2.24, J2.26, J2.28, J2.30, J2.32, J2.34, J2.36, J2.38, J2.40, JReset1.1, R8.2, R9.2, U1.14 (GND1), U1.20 (GND3), U1.26 (GND2), U2.12, U2.13, U3.5 (NC), U3.6 (NC), U3.7 (NC), U3.8 (NC), U3.9 (NC), U3.10 (NC), U3.11 (NC), U3.12 (NC), U3.13 (GND)
unnamed: 5VDC_IN1.2, F1.1
unnamed: BT1.1, U3.14 (Vbatt)
unnamed: C11.1, U1.2 (EN)
unnamed: ExtPower1.2, U1.19 (EXT_5V)
unnamed: J1.37, SDA_EXT1.1
unnamed: J1.39, SCL_EXT1.1
unnamed: J3.1, U1.32 (IO4)
unnamed: JReset1.2, U3.4 (RST)
unnamed: R3.1, U1.12 (IO14)
unnamed: R4.1, U1.11 (IO27)
unnamed: R5.1, U1.10 (IO26)
unnamed: R6.1, U1.9 (IO25)
unnamed: R7.1, U1.8 (IO33)
unnamed: R8.1, S1.1, U1.5 (IO34)
unnamed: R9.1, S2.1, U1.6 (IO35)
unnamed: R10.1, U1.13 (IO12)
unnamed: SCL1.2, U2.5
unnamed: SCL2.1, U3.16 (SCL)
unnamed: SDA1.2, U2.4
unnamed: SDA2.1, U3.15 (SDA)

Notes on the sheet:
Reserved Function

Board: 2 copper layers, 100.0 x 100.0 mm, 43 parts (0 on the bottom side), 31 nets.

File ESP Backpack/Gerbers/ESP backpack-BOM-rev00.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"S1,S2";"452403012014";2;"452403012014";;;
2;"D1";"LED_SK6812";1;"SK6812";;;
3;"U1";"MODULE_ESP32-DEVKITC-32D";1;"ESP32-DEVKITC-32D";;;
4;"J1,J2";"SAMTEC_HLE-120-02-F-DV-BE-K";2;"HLE-120-02-F-DV-BE-K";;;
5;"5VDC_IN1";"TE_282837-4";1;"282837-4";;;
6;"C6,C3,C4,C5,C7,C8,C9,C10,C11,C12,C13,C14";"CAP_EEE0JA102P";12;"EEE0JA102P";;;
7;"C1";"C_0603_1608Metric";1;"10uF";;;
8;"C2";"C_0805_2012Metric";1;"0.1uF";;;
9;"ExtPower1,SCL1,SCL_EXT1,SDA1,SDA_EXT1";"R_0603_1608Metric";5;"0ohm";;;
10;"R2,R1,R8,R9";"R_0603_1608Metric";4;"10k";;;
11;"R7,R6,R5,R4,R3,R10";"R_0603_1608Metric";6;"470";;;
12;"U2";"XDCR_VCNL4010-GS08";1;"VCNL4010-GS08";;;

## Commit log

2021-11-23 add files to baseline to rev00 as sent to fab
2021-12-17 Re-org files for relative pathing, change extensions for globally unique names
2021-12-19 change paths to sort to top of list
2021-12-19 change 3d models to relative
2021-12-20 add VCNL step files
2021-12-20 fix wurth switches in #13
2021-12-21 edit all libs and footprints into single libraries and files. Issue fixes
2021-12-22 change zones to include pad specific overrides
2021-12-22 edit weird fill issue
2021-12-22 add step file for 3d reference
2021-12-29 update docs to include fab instructions
2021-12-29 add better fab docs
2023-02-01 reorg to more standard file tree
2023-04-15 reorg into more traditional arrangement
2023-04-15 fixes #17, #18, #15 and adds RTC
2023-04-15 add outputs
2023-04-15 update outputs
2023-07-19 fix paths
